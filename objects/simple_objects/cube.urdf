Commit message: image update

File: objects/simple_objects/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base: geometry collision box size=0.05 0.05 0.05; visual box size=0.05 0.05 0.05
