Commit message: feat(objects): fridge

File: src/objects/collab_objects/fridge.urdf (robot description, URDF)
Before this commit: robot fridge_bottom, 3 links, 2 joints
Links:
- link cabinet: geometry collision box size=0.01 0.3 0.366; collision box size=0.2 0.01 0.366
